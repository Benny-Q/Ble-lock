# Keil uVision project S500.uvprojx, settings and files
target S500 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: S500 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: .\User;.\STM32F0_Discovery_Library;.\STM32F0_Discovery_Library\CMSIS\Include;.\STM32F0_Discovery_Library\CMSIS\ST\STM32F0xx\Include;.\STM32F0_Discovery_Library\STM32F0xx_StdPeriph_Driver\inc;.\Hardware;.\Flash;.\FingerPrint;.\Control;.\APT8L16;.\LED;.\Motor;.\OLED;.\Speak;.\RC522;.\Bluetooth
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Cortex M0
    ./STM32F0_Discovery_Library/CMSIS/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group System
    ./STM32F0_Discovery_Library/: stm32f0_discovery.c stm32f0xx_it.c system_stm32f0xx.c
  group stmLIB
    ./STM32F0_Discovery_Library/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ./User/: main.c regtarge.c delay.c ble.c
  group Hardware
    ./Hardware/: bsp_usart2.c bsp_usart1.c bsp_TiMbase.c bsp_key.c bsp_ADC.c bsp_RTC.c
  group LED
    ./LED/: bsp_LED.c
  group Control
    ./Control/: bsp_Config.c Information_Check.c Sleep_system.c Config_Menu.c
  group APT8L16
    ./APT8L16/: APT8L16.c
  group FingerPrint
    ./FingerPrint/: FingerPrint.c
  group RFID
    ./RC522/: rc522_config.c rc522_function.c RFID_main.c
  group Motor
    ./Motor/: Motor.c
  group Speak
    ./Speak/: audio.c
  group Flash
    ./Flash/: Flash.c Flash.h
  group Bluetooth
    ./Bluetooth/: Bluetooth.c
